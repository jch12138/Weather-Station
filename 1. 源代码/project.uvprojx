# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32l4xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32l4xx
  AfterMake: fromelf --bin !L --output rt-thread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32L475xx
  c include: .;rt-thread\include;.;applications;drivers;libraries\CMSIS\Device\ST\STM32L4xx\Include;libraries\CMSIS\Include;libraries\STM32L4xx_HAL_Driver\inc;libraries\rt_ota\inc;libraries\wifi;ports\wifi;packages\cJSON-v1.0.2;packages\EasyFlash-v4.1.0\inc;ports\easyflash;packages\fal-v0.5.0\inc;ports\fal;packages\gbk2utf8-latest\inc;packages\netutils-v1.2.0\ntp;packages\stm32_sdio-v1.0.2;packages\webclient-v2.1.2\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\wlan;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\termios;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: asr.c bmp.c main.c ui.c weather.c wifi.c
  group Drivers
    drivers/: board.c drv_clock.c sdcard_port.c display_ch.c drv_gpio.c drv_qspi_flash.c drv_spi_tfcard.c drv_lcd.c drv_usart.c drv_spi.c drv_sdio_adapter.c drv_qspi.c drv_wlan.c
  group STM32L4xx_HAL_Driver
    libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group rt_ota
    libraries/rt_ota/libs/: librt_ota_noalgo_0.1.2_stm32l4_keil.lib
  group wifi
    ports/wifi/: wifi_config.c
  group wifi
    libraries/wifi/: libwifi_6181_0.2.5_armcm4_keil.lib
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group EasyFlash
    packages/EasyFlash-v4.1.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
  group GBK2UTF8
    packages/gbk2utf8-latest/src/: gbk2utf8.c
  group NetUtils
    packages/netutils-v1.2.0/ntp/: ntp.c
  group stm32_sdio
    packages/stm32_sdio-v1.0.2/: stm32_sdio.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    rt-thread/components/libc/compilers/common/: gmtime_r.c
    rt-thread/components/libc/termios/: posix_termios.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
software components: CMSIS:CORE 5.0.1
